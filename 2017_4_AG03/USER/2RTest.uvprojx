# Keil uVision project 2RTest.uvprojx, settings and files
target Targets (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: GD32F103RB GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 2RTest +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_XL
  c include: ..\USER;..\CMSIS;..\CMSIS\inc;..\StartUp;..\App\Arr_C_M;.\Main;..\App\Detection;..\App\Extra;..\App\it;..\App\OLED;..\App\Start;..\CMSIS;..\App\USART;..\App\TPG;..\FATFS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ../App/Start/: Start.c Hardware_Init.c
    ../App/USART/: UsartPrintf.c
    ../App/Arr_C_M/: MOTO.c C_M.h Cap.c
    ../App/Extra/: Delay.c BEEP_LED.c
    ../App/it/: stm32f10x_it.c
    ../App/Detection/: Detect_ADC.c
    ../App/TPG/: TPG.c
    ../App/OLED/: OLED.c zk.c OLED_Print.c
  group CMSIS
    ../CMSIS/: core_cm3.c
    ../CMSIS/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group StartUp
    ../StartUp/: system_stm32f10x.c startup_stm32f10x_xl.s
  group Main
    ./Main/: main.c Config.h
